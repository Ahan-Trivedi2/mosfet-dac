v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 160 -310 310 -310 {lab=Vbp}
N 310 -310 310 -250 {lab=Vbp}
N 310 -250 350 -250 {lab=Vbp}
N 350 -250 360 -250 {lab=Vbp}
N 360 -250 370 -250 {lab=Vbp}
N 470 -180 490 -180 {lab=Vout}
N 150 -60 170 -60 {lab=Vbp}
N 270 -220 290 -220 {lab=Vcp}
N 470 -220 490 -220 {lab=Vcp}
N 350 -220 370 -220 {lab=Vcn}
N 150 -230 150 -60 {lab=Vbp}
N 150 -310 150 -230 {lab=Vbp}
N 150 -310 160 -310 {lab=Vbp}
N 120 -190 170 -190 {lab=Vbn}
N 120 -230 150 -230 {lab=Vbp}
N 310 -60 360 -60 {lab=Vbp}
N 310 -250 310 -60 {lab=Vbp}
N 340 -10 370 -10 {lab=#net1}
N 360 -60 370 -60 {lab=Vbp}
N 490 -310 490 -220 {lab=Vcp}
N 330 -310 490 -310 {lab=Vcp}
N 330 -310 330 -220 {lab=Vcp}
N 290 -220 330 -220 {lab=Vcp}
N 350 -220 350 -30 {lab=Vcn}
N 330 -200 370 -200 {lab=#net2}
N 150 10 150 70 {lab=#net1}
N 150 70 340 70 {lab=#net1}
N 340 -10 340 70 {lab=#net1}
N 330 -200 330 -120 {lab=#net2}
N 120 -120 330 -120 {lab=#net2}
N 120 -120 120 -20 {lab=#net2}
N 290 -30 370 -30 {lab=Vcn}
N 270 -30 290 -30 {lab=Vcn}
N 70 -20 120 -20 {lab=#net2}
N 70 10 150 10 {lab=#net1}
N -860 120 -820 120 {lab=b0}
N -1030 180 -990 180 {lab=Vout}
N -1000 150 -990 150 {lab=VN}
N -1030 150 -1000 150 {lab=VN}
N -1030 120 -990 120 {lab=VP}
N -1030 210 -990 210 {lab=Vg}
N -860 150 -820 150 {lab=b1}
N -860 180 -820 180 {lab=b2}
N -860 210 -820 210 {lab=b3}
N -860 240 -820 240 {lab=b4}
N -860 270 -820 270 {lab=b5}
N -860 300 -820 300 {lab=b6}
N -1030 240 -990 240 {lab=Res}
N -550 20 -460 20 {lab=#net3}
N -520 -250 -490 -250 {lab=Vg}
N -520 -280 -520 -250 {lab=Vg}
N -460 -280 -450 -280 {lab=#net4}
N -530 -280 -520 -280 {lab=Vg}
N -450 -250 -420 -250 {lab=#net4}
N -450 -280 -450 -250 {lab=#net4}
N -700 200 10 200 {lab=VN}
N -700 160 10 160 {lab=Vg}
N 10 160 140 160 {lab=Vg}
N 10 200 140 200 {lab=VN}
N -390 -280 -390 -250 {lab=VN}
N -590 -280 -590 -250 {lab=VP}
N -520 -340 -490 -340 {lab=Vg}
N -520 -370 -520 -340 {lab=Vg}
N -460 -370 -450 -370 {lab=#net4}
N -530 -370 -520 -370 {lab=Vg}
N -450 -340 -420 -340 {lab=#net4}
N -450 -370 -450 -340 {lab=#net4}
N -390 -370 -390 -340 {lab=VN}
N -390 -340 -390 -280 {lab=VN}
N -450 -340 -450 -280 {lab=#net4}
N -520 -340 -520 -280 {lab=Vg}
N -590 -370 -590 -280 {lab=VP}
N -560 -340 -560 -240 {lab=Vbp}
N -290 -250 -260 -250 {lab=Vg}
N -260 -280 -260 -250 {lab=Vg}
N -330 -280 -320 -280 {lab=#net5}
N -260 -280 -250 -280 {lab=Vg}
N -360 -250 -330 -250 {lab=#net5}
N -330 -280 -330 -250 {lab=#net5}
N -190 -280 -190 -250 {lab=VP}
N -290 -340 -260 -340 {lab=Vg}
N -260 -370 -260 -340 {lab=Vg}
N -330 -370 -320 -370 {lab=#net5}
N -260 -370 -250 -370 {lab=Vg}
N -360 -340 -330 -340 {lab=#net5}
N -330 -370 -330 -340 {lab=#net5}
N -330 -340 -330 -280 {lab=#net5}
N -260 -340 -260 -280 {lab=Vg}
N -190 -370 -190 -280 {lab=VP}
N -220 -340 -220 -240 {lab=Vbp}
N -490 -250 -490 -210 {lab=Vg}
N -490 -210 -260 -210 {lab=Vg}
N -260 -250 -260 -210 {lab=Vg}
N -220 -240 -220 -200 {lab=Vbp}
N -560 -200 -220 -200 {lab=Vbp}
N -560 -240 -560 -200 {lab=Vbp}
N -590 -250 -590 -160 {lab=VP}
N -590 -160 -190 -160 {lab=VP}
N -190 -250 -190 -160 {lab=VP}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_bbg.sym} 40 -160 0 0 {name=X1}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_ccm.sym} 380 -150 0 0 {name=X2}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_ncbc.sym} 170 30 0 0 {name=X3}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_pcbc.sym} 170 -160 0 0 {name=X4}
C {lab_pin.sym} 290 -220 1 0 {name=p3 sig_type=std_logic lab=Vcp}
C {lab_pin.sym} 130 -190 3 0 {name=p5 sig_type=std_logic lab=Vbn}
C {lab_pin.sym} 150 -310 0 0 {name=p26 sig_type=std_logic lab=Vbp}
C {lab_pin.sym} 80 -260 1 0 {name=p4 sig_type=std_logic lab=VP}
C {lab_pin.sym} 80 -160 3 0 {name=p7 sig_type=std_logic lab=VN}
C {lab_pin.sym} 220 30 3 0 {name=p11 sig_type=std_logic lab=VN}
C {lab_pin.sym} 410 40 3 0 {name=p12 sig_type=std_logic lab=VN}
C {lab_pin.sym} 410 -150 3 0 {name=p13 sig_type=std_logic lab=VN}
C {lab_pin.sym} 220 -160 3 0 {name=p14 sig_type=std_logic lab=VN}
C {lab_pin.sym} 220 -90 1 0 {name=p15 sig_type=std_logic lab=VP}
C {lab_pin.sym} 410 -90 1 0 {name=p16 sig_type=std_logic lab=VP}
C {lab_pin.sym} 410 -280 1 0 {name=p30 sig_type=std_logic lab=VP}
C {lab_pin.sym} 220 -280 1 0 {name=p31 sig_type=std_logic lab=VP}
C {lab_pin.sym} 490 -180 2 0 {name=p1 sig_type=std_logic lab=Vout}
C {lab_pin.sym} 50 -160 3 0 {name=p51 sig_type=std_logic lab=Res}
C {lab_pin.sym} 290 -30 1 0 {name=p6 sig_type=std_logic lab=Vcn}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_fvf.sym} 370 40 0 0 {name=X5}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_dac.sym} -390 80 0 0 {name=X6}
C {lab_pin.sym} -420 80 3 0 {name=p8 sig_type=std_logic lab=VN}
C {lab_pin.sym} -820 120 2 0 {name=p9 sig_type=std_logic lab=b0}
C {lab_pin.sym} -990 150 2 0 {name=p27 sig_type=std_logic lab=VN
}
C {lab_pin.sym} -990 120 2 0 {name=p28 sig_type=std_logic lab=VP
}
C {lab_pin.sym} -990 180 2 0 {name=p32 sig_type=std_logic lab=Vout
}
C {iopin.sym} -1030 120 2 0 {name=p33 lab=VP}
C {iopin.sym} -1030 150 2 0 {name=p34 lab=VN}
C {opin.sym} -1030 180 2 0 {name=p35 lab=Vout}
C {ipin.sym} -860 120 0 0 {name=p36 lab=b0}
C {lab_pin.sym} -990 210 2 0 {name=p37 sig_type=std_logic lab=Vg
}
C {opin.sym} -1030 210 2 0 {name=p38 lab=Vg}
C {ipin.sym} -860 150 0 0 {name=p40 lab=b1}
C {ipin.sym} -860 180 0 0 {name=p42 lab=b2}
C {ipin.sym} -860 210 0 0 {name=p44 lab=b3}
C {ipin.sym} -860 240 0 0 {name=p46 lab=b4}
C {ipin.sym} -860 270 0 0 {name=p48 lab=b5}
C {ipin.sym} -860 300 0 0 {name=p50 lab=b6}
C {lab_pin.sym} -820 150 0 1 {name=p39 sig_type=std_logic lab=b1}
C {lab_pin.sym} -820 180 0 1 {name=p41 sig_type=std_logic lab=b2}
C {lab_pin.sym} -820 210 0 1 {name=p43 sig_type=std_logic lab=b3}
C {lab_pin.sym} -820 240 0 1 {name=p45 sig_type=std_logic lab=b4}
C {lab_pin.sym} -820 270 0 1 {name=p47 sig_type=std_logic lab=b5}
C {lab_pin.sym} -820 300 0 1 {name=p49 sig_type=std_logic lab=b6}
C {lab_pin.sym} -990 240 2 0 {name=p52 sig_type=std_logic lab=Res
}
C {opin.sym} -1030 240 2 0 {name=p53 lab=Res}
C {lab_pin.sym} -580 -10 0 0 {name=p20 sig_type=std_logic lab=Vbp}
C {madvlsi/pmos3.sym} -550 -10 0 0 {name=M1
L=1
W=1
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -550 -40 1 0 {name=p10 sig_type=std_logic lab=VP
}
C {madvlsi/nmos3.sym} -420 -280 3 0 {name=M2
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -390 -250 3 0 {name=p57 sig_type=std_logic lab=VN}
C {madvlsi/pmos3.sym} -560 -280 3 0 {name=M3
L=3
W=0.45
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -490 -280 3 0 {name=M4
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -590 -160 3 0 {name=p59 sig_type=std_logic lab=VP}
C {lab_pin.sym} -560 -200 3 0 {name=p56 sig_type=std_logic lab=Vbp}
C {lab_pin.sym} -520 -250 3 0 {name=p2 sig_type=std_logic lab=Vg
}
C {lab_pin.sym} -460 -20 0 0 {name=p17 sig_type=std_logic lab=Vg
}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_inverter.sym} -620 180 0 0 {name=X7}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_inverter.sym} -480 180 0 0 {name=X8}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_inverter.sym} -340 180 0 0 {name=X9}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_inverter.sym} -200 180 0 0 {name=X10}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_inverter.sym} 80 180 0 0 {name=X11}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_inverter.sym} -60 180 0 0 {name=X12}
C {/home/madvlsi/Documents/mosfet-dac/LDS/LDS_inverter.sym} -760 180 0 0 {name=X13}
C {lab_pin.sym} -730 180 0 0 {name=p18 sig_type=std_logic lab=b0}
C {lab_pin.sym} -590 180 0 0 {name=p19 sig_type=std_logic lab=b1}
C {lab_pin.sym} -700 200 3 0 {name=p21 sig_type=std_logic lab=VN}
C {lab_pin.sym} -700 160 1 0 {name=p22 sig_type=std_logic lab=Vg
}
C {lab_pin.sym} -450 180 2 1 {name=p23 sig_type=std_logic lab=b2}
C {lab_pin.sym} -670 180 2 0 {name=p24 sig_type=std_logic lab=bn0}
C {lab_pin.sym} -530 180 2 0 {name=p25 sig_type=std_logic lab=bn1}
C {lab_pin.sym} -390 180 2 0 {name=p29 sig_type=std_logic lab=bn2}
C {lab_pin.sym} -310 180 2 1 {name=p54 sig_type=std_logic lab=b3}
C {lab_pin.sym} -250 180 2 0 {name=p55 sig_type=std_logic lab=bn3}
C {lab_pin.sym} -170 180 2 1 {name=p58 sig_type=std_logic lab=b4}
C {lab_pin.sym} -110 180 2 0 {name=p60 sig_type=std_logic lab=bn4}
C {lab_pin.sym} -30 180 2 1 {name=p61 sig_type=std_logic lab=b5}
C {lab_pin.sym} 30 180 2 0 {name=p62 sig_type=std_logic lab=bn5}
C {lab_pin.sym} 110 180 2 1 {name=p63 sig_type=std_logic lab=b6}
C {lab_pin.sym} 170 180 2 0 {name=p64 sig_type=std_logic lab=bn6}
C {lab_pin.sym} -390 80 1 1 {name=p65 sig_type=std_logic lab=b6}
C {lab_pin.sym} -360 80 3 0 {name=p66 sig_type=std_logic lab=bn6}
C {lab_pin.sym} -330 80 1 1 {name=p67 sig_type=std_logic lab=b5}
C {lab_pin.sym} -300 80 3 0 {name=p68 sig_type=std_logic lab=bn5}
C {lab_pin.sym} -270 80 1 1 {name=p69 sig_type=std_logic lab=b4}
C {lab_pin.sym} -240 80 3 0 {name=p70 sig_type=std_logic lab=bn4}
C {lab_pin.sym} -210 80 1 1 {name=p71 sig_type=std_logic lab=b3}
C {lab_pin.sym} -180 80 3 0 {name=p72 sig_type=std_logic lab=bn3}
C {lab_pin.sym} -150 80 1 1 {name=p73 sig_type=std_logic lab=b2}
C {lab_pin.sym} -120 80 3 0 {name=p74 sig_type=std_logic lab=bn2}
C {lab_pin.sym} -90 80 3 0 {name=p75 sig_type=std_logic lab=b1}
C {lab_pin.sym} -60 80 3 0 {name=p76 sig_type=std_logic lab=bn1}
C {lab_pin.sym} 0 80 3 0 {name=p77 sig_type=std_logic lab=bn0}
C {lab_pin.sym} -30 80 3 0 {name=p78 sig_type=std_logic lab=b0}
C {madvlsi/nmos3.sym} -420 -370 3 0 {name=M5
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -560 -370 3 0 {name=M6
L=3
W=0.45
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -490 -370 3 0 {name=M7
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -360 -280 1 1 {name=M8
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -220 -280 1 1 {name=M9
L=3
W=0.45
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -290 -280 1 1 {name=M10
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -360 -370 1 1 {name=M11
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -220 -370 1 1 {name=M12
L=3
W=0.45
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -290 -370 1 1 {name=M13
L=1
W=1
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}

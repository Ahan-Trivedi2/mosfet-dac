v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {bbg.sym} 20 -30 0 0 {name=X1}
C {cbc.sym} 140 -30 0 0 {name=X2}
C {fvf.sym} -50 -10 0 0 {name=X3}
